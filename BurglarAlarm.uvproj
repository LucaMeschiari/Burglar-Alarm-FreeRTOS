# Keil uVision project BurglarAlarm.uvproj, settings and files
target Internal Flash Memory (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FreeRTOSConsole
  c flags: Optim=1
  c define: ARM7_LPC2468_TCD
  c include: .;..\FreeRTOS\Source\portable\TCD\ARM7_LPC2468;..\FreeRTOS\Demo\Common\include;..\FreeRTOS\Source\include;.\LCD
  asm include: ..\FreeRTOS\Source\portable\TCD\ARM7_LPC2468
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2400.s
  group Application Code
    ./: main.c Retarget.c console.c serial.c serialISR.s lcd.c lcdISR.s sensors.c manTask.c manTask.h Timer.c Timer.h
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/TCD/ARM7_LPC2468/: port.c portASM.s portmacro.h portmacro.inc
    ../FreeRTOS/Source/portable/MemMang/: heap_3.c
    ./: FreeRTOSConfig.h
  group LCD
    ./LCD/: font5x7.c lcd_grph.c lcd_hw.c
target External SDRAM (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: FreeRTOSConsole
  c flags: Optim=1
  c define: ARM7_LPC2468_TCD
  c include: as above
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  asm include: ..\FreeRTOS\Source\portable\TCD\ARM7_LPC2468
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target Simulator (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: FreeRTOSConsole
  c flags: Optim=1
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
